# Keil uVision project example.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.2.0
  cpu: CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: example +hex
  AfterMake: fromelf --vhx --32x1 -o .\example.bin .\example.axf
  c flags: Optim=1 wLevel=2
  c include: ..\head
  asm include: ..\head;..\startup
  memory RVCT4: ROM 0x0 size 0x800
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: startup_NUC122.s systeminit.c jump2iap.c mpu.c
software components: CMSIS:CORE 3.30.0
