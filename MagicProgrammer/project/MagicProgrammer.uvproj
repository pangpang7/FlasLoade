# Keil uVision project MagicProgrammer.uvproj, settings and files
target MagicProgrammer (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MagicProgrammer +hex
  c flags: Optim=4 oTime=1 OneElfS=1
  c include: ..\include;..\USB;..\include\STM32F10x;..\Swd
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20008000 size 0x8000
  group Application files
    ../source/: hw_config.c main.c stm32f10x_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c BLSlave.c OfflineDownloadCtrl.c sw_lib.c SPI.c STC.c UART.c SWD.c
  group USBLib
    ../USB/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group FWLib
    ../lib/: STM32F10xR.LIB
  group RVMDK
    ./: stm32f10x_vector.s
  group Doc
    ../: readme.txt
  group Swd
    ../Swd/: DAP.c SW_DP.c swd_host.c target_reset.c
