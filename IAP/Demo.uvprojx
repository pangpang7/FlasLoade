# Keil uVision project Demo.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: Demo +hex
  AfterMake: fromelf --bin -o .\si6600iap.bin .\Demo.axf
  AfterMake: bintoc si6600iap .\si6600iap.bin > .\si6600iap.c
  c flags: Optim=4 wLevel=2
  c include: .\DEVICE;.\USER
  memory RVCT4: ROM 0xa003f800 size 0x800
  memory RVCT9: RAM 0x20000000 size 0x20000
  group DEVICE
    ./DEVICE/: system_SI6600.c startup_SI6600.s
  group USER
    ./USER/: readme.txt sysclk.c uart_demo2.c UartSlave.c sw_lib.c
software components: CMSIS:CORE 4.1.0
