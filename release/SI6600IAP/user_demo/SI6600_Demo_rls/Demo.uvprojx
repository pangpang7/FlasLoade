# Keil uVision project Demo.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: Demo +hex
  AfterMake: fromelf --vhx --32x1 -o .\Demo.bin .\Demo.axf
  c flags: Optim=1 wLevel=2
  c include: .\DEVICE;.\USER
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group DEVICE
    ./DEVICE/: system_SI6600.c startup_SI6600.s
  group USER
    ./USER/: readme.txt sysclk.c gpio_demo1.c
  group IAP
    ./IAP/: si6600iap.c
software components: CMSIS:CORE 4.1.0
