# Keil uVision project SI6600_FLH.uvprojx, settings and files
target Si6600_1 (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.1.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: SI6600_FLH +hex
  AfterMake: cmd.exe /C copy SI6600_FLH.axf ..\SI6600.FLM
  AfterMake: fromelf --vhx --32x1 -o .\Objects\SI6600_FLH.bin .\Objects\SI6600_FLH.axf
  c flags: Optim=1 wLevel=2
  c define: FLASH_MEM, STM32F10x_512
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  group Programp Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
