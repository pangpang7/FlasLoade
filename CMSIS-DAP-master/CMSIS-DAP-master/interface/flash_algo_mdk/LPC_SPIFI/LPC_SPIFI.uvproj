# Keil uVision project LPC_SPIFI.uvproj, settings and files
target LPC1800_SPIFI_8M_4K (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: flash_algo
  c flags: Optim=3
  c define: LPC1800_SPIFI,SPIFI_8M_4K,USE_SPIFI_LIB
  c misc: --diag_suppress 3017
  scatter file: .\Target.lin
  link misc: --entry 1 --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group SPIFI Lib
    ./: spifi_drv_PI.lib
target LPC1800_SPIFI_4M_4K (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: flash_algo
  c flags: Optim=3
  c define: LPC1800_SPIFI,SPIFI_4M_4K,USE_SPIFI_LIB
  c misc: --diag_suppress 3017
  scatter file: .\Target.lin
  link misc: --entry 1 --diag_suppress L6305
target LPC1800_SPIFI_4M_64K (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: flash_algo
  c flags: Optim=3
  c define: LPC1800_SPIFI,SPIFI_4M_64K,USE_SPIFI_LIB
  c misc: --diag_suppress 3017
  scatter file: .\Target.lin
  link misc: --entry 1 --diag_suppress L6305
